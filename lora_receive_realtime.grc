options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: lora_receive_realtime
    output_language: python
  states: {}

blocks:
- name: bitrate
  id: variable
  parameters:
    value: sf * (1 / (2**sf / float(bw)))
  states: {}
- name: bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: capture_freq
  id: variable
  parameters:
    value: 866.0e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: symbols_per_sec
  id: variable
  parameters:
    value: float(bw) / (2**sf)
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 868.1e6
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: lora_lora_receiver_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: capture_freq
    channel_list: '[target_freq]'
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '10'
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: sf
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: capture_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: capture_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    type: complex
    update_time: '0.01'
  states: {}

connections:
- [blocks_throttle_0, '0', lora_lora_receiver_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
